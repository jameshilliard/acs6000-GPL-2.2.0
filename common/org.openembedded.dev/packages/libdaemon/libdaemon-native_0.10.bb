require libdaemon_${PV}.bb
inherit native

S="${WORKDIR}/libdaemon-${PV}"

