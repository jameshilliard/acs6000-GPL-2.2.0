DESCRIPTION = "NTP utilities"
SECTION = "base"
PRIORITY = "optional"
HOMEPAGE = "http://www.ntp.org"

SRC_URI = " http://www.eecis.udel.edu/~ntp/ntp_spool/ntp4/ntp-4.2.4p3.tar.gz\
	"
inherit autotools
