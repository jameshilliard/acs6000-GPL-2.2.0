inherit native
require xerces-c_${PV}.bb

PACKAGES = ""
PROVIDES = ""

do_install () {
	:
}
