require llconf.bb
inherit native

S="${WORKDIR}/llconf"
